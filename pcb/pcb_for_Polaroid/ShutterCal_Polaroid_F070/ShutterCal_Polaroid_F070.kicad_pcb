# Repository ZeshuLiu/ShutterSpeedCalibrator

## KiCad design pcb/pcb_for_Polaroid/ShutterCal_Polaroid_F070/ShutterCal_Polaroid_F070.kicad_pcb

Parts:
C1: (0.7pF); C_0603_1608Metric
C2: 1uF; C_0603_1608Metric
C3, C5: 100nF; C_0603_1608Metric
C4: 4.7uF; C_0603_1608Metric
C6, C7: 22uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1: SFH2440; Osram_SFH2440
J1: Conn_Coaxial; U.FL_Hirose_U.FL-R-SMT-1_Vertical
J2, J4, J5: Conn_01x04_Socket; PinSocket_1x04_P2.54mm_Horizontal
J3: USB_C_Receptacle_USB2.0; USB_C_Receptacle_HRO_TYPE-C-31-M-12
JP1: Jumper_2_Open; TestPoint_2Pads_Pitch2.54mm_Drill0.8mm
R1: (240k); R_0603_1608Metric
R2: 91k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R3: 150k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R4: 330k; R_0603_1608Metric
R5: 6.8k; R_0603_1608Metric
R6: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R7: (1k)DNF; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
TP1: REF0; TestPoint_Pad_D1.5mm
U1: OPA365xxDBV; SOT-23-5
U4: AMS1117-3.3; SOT-223-3_TabPin2
U5: STM32F070F6Px; TSSOP-20_4.4x6.5mm_P0.65mm

Connections:
+3.3V: C3.1, C4.1, C6.1, J2.4, J4.1, J5.1, U4.2 (VO), U5.16 (VDD)
+5V: C7.1, J3.A4 (VBUS), J3.A9 (VBUS), J3.B4 (VBUS), J3.B9 (VBUS), R5.2, U1.5 (V+), U4.3 (VI)
/ADC1_IN0: R2.2, R3.1, U5.6 (PA0)
/ADC1_IN1: U5.7 (PA1)
/I2C2_SCL: J4.2, U5.3 (PF1)
/I2C2_SDA: J4.3, U5.2 (PF0)
/Light_out: C1.2, J1.1 (In), R1.2, R2.1, U1.1
/NRST: C5.2, JP1.2 (B), U5.4 (NRST)
/SWCLK: J2.2, U5.20 (PA14)
/SWDIO: J2.3, U5.19 (PA13)
/UART2_RX: J5.3, U5.9 (PA3)
/UART2_TX: J5.2, U5.8 (PA2)
/USB+: J3.A6 (D+), J3.B6 (D+), U5.18 (PA10/PA12)
/USB-: J3.A7 (D-), J3.B7 (D-), U5.17 (PA9/PA11)
GND: C2.2, C3.2, C4.2, C5.1, C6.2, C7.2, D1.2 (A), J1.2 (Ext), J2.1, J3.A1 (GND), J3.A12 (GND), J3.B1 (GND), J3.B12 (GND), J3.S1 (SHIELD), J4.4, J5.4, JP1.1 (A), R3.2, R4.1, R6.2, R7.2, U1.2 (V-), U4.1 (GND), U5.15 (VSS)
unnamed: C1.1, D1.1 (K), R1.1, U1.4 (-)
unnamed: J3.A5 (CC1), R6.1
unnamed: J3.B5 (CC2), R7.1
unnamed: C2.1, R4.2, R5.1, TP1.1, U1.3 (+)

Notes on the sheet:
光电二级管

Board: 2 copper layers, 85.7 x 87.0 mm, 25 parts (24 on the bottom side), 18 nets.

## KiCad design pcb/pcb_for_Polaroid/ShutterCal_Polaroid/ShutterCal_Polaroid.kicad_pcb

Board: 2 copper layers, 84.7 x 87.0 mm, 34 parts (33 on the bottom side), 22 nets.

Parts:
C1: (0.7pF); C_0603_1608Metric
C2: 1uF; C_0603_1608Metric
C3, C5, C8, C9: 100nF; C_0603_1608Metric
C4: 4.7uF; C_0603_1608Metric
C6, C7: 22uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1: SFH2440; Osram_SFH2440
D2: SMF5V0A; D_SMF
F1: 0.5A; Fuse_1206_3216Metric
J1: Conn_Coaxial; U.FL_Hirose_U.FL-R-SMT-1_Vertical
J2, J4, J5: Conn_01x04_Socket; PinSocket_1x04_P2.54mm_Horizontal
J3: USB_C_Receptacle_USB2.0; USB_C_Receptacle_HRO_TYPE-C-31-M-12
J6, J9: Conn_01x04_Shielded; Molex_200528-0040_1x04-1MP_P1.00mm_Horizontal
J7: Conn_01x02_Socket; PinHeader_1x02_P2.54mm_Vertical
JP1: Jumper_2_Open; TestPoint_2Pads_Pitch2.54mm_Drill0.8mm
R1: (240k); R_0603_1608Metric
R2: 91k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R3: 150k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R4: 330k; R_0603_1608Metric
R5: 6.8k; R_0603_1608Metric
R6, R8: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R7: (1k)DNF; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
TP1: REF0; TestPoint_Pad_D1.5mm
U1: OPA365xxDBV; SOT-23-5
U2: STM32G030F6Px; TSSOP-20_4.4x6.5mm_P0.65mm
U3: CH340N; SOP-8_3.9x4.9mm_P1.27mm
U4: AMS1117-3.3; SOT-223-3_TabPin2

Connections:
+3.3V: C3.1, C4.1, C6.1, C8.1, C9.1, J2.4, J4.1, J5.1, J6.1, J9.1, R8.2, U2.4 (VDD), U3.5 (VCC), U3.8 (V3), U4.2 (VO)
+5V: C7.1, D2.1 (A1), F1.2, R5.2, U1.5 (V+), U4.3 (VI)
/5V_IN: F1.1, J3.A4 (VBUS), J3.A9 (VBUS), J3.B4 (VBUS), J3.B9 (VBUS), J7.1
/ADC1_IN6: R2.2, R3.1, U2.13 (PA6)
/ADC1_IN7: R8.1, U2.14 (PA7)
/I2C2_SCL: J4.2, J9.2, U2.16 (PA11/PA9)
/I2C2_SDA: J4.3, J9.3, U2.17 (PA12/PA10)
/Light_out: C1.2, J1.1 (In), R1.2, R2.1, U1.1
/NRST: C5.2, JP1.2 (B), U2.6 (NRST)
/SWCLK: J2.2, U2.19 (PA14/PA15)
/SWDIO: J2.3, U2.18 (PA13)
/UART1_RX: U2.1 (PB7/PB8), U3.6 (TXD)
/UART1_TX: U2.20 (PB3/PB4/PB5/PB6), U3.7 (RXD)
/UART2_RX: J5.3, J6.3, U2.10 (PA3)
/UART2_TX: J5.2, J6.2, U2.9 (PA2)
/USB+: J3.A6 (D+), J3.B6 (D+), U3.1 (UD+)
/USB-: J3.A7 (D-), J3.B7 (D-), U3.2 (UD-)
GND: C2.2, C3.2, C4.2, C5.1, C6.2, C7.2, C8.2, C9.2, D1.2 (A), D2.2 (A2), J1.2 (Ext), J2.1, J3.A1 (GND), J3.A12 (GND), J3.B1 (GND), J3.B12 (GND), J3.S1 (SHIELD), J4.4, J5.4, J6.4, J6.SH (Shield), J7.2, J9.4, J9.SH (Shield), JP1.1 (A), R3.2, R4.1, R6.2, R7.2, U1.2 (V-), U2.5 (VSS), U3.3 (GND), U4.1 (GND)
unnamed: C1.1, D1.1 (K), R1.1, U1.4 (-)
unnamed: J3.A5 (CC1), R6.1
unnamed: J3.B5 (CC2), R7.1
unnamed: C2.1, R4.2, R5.1, TP1.1, U1.3 (+)

File pcb/pcb_for_Polaroid/ShutterCal_Polaroid/production/ShutterCal_Polaroid_2024-02-21_21-11-25/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
C1,0603,1,(0.7pF),
C2,0603,1,1uF,
"C3, C5, C8, C9",0603,4,100nF,
C4,0603,1,4.7uF,
"C6, C7",0805,2,22uF,
D1,Osram_SFH2440,1,SFH2440,
D2,D_SMF,1,SMF5V0A,
F1,1206,1,0.5A,
J1,U.FL_Hirose_U.FL-R-SMT-1_Vertical,1,Conn_Coaxial,
"J2, J4, J5",PinSocket_1x04_P2.54mm_Horizontal,3,Conn_01x04_Socket,
J3,USB_C_Receptacle_HRO_TYPE-C-31-M-12,1,USB_C_Receptacle_USB2.0,
JP1,TestPoint_2Pads_Pitch2.54mm_Drill0.8mm,1,Jumper_2_Open,
R1,0603,1,(240k),
R2,0805,1,91k,
R3,0805,1,150k,
R4,0603,1,330k,
R5,0603,1,6.8k,
"R6, R8",0805,2,1k,
R7,0805,1,(1k)DNF,
TP1,TestPoint_Pad_D1.5mm,1,REF0,
U1,SOT-23-5,1,OPA365xxDBV,
U2,TSSOP-20_4.4x6.5mm_P0.65mm,1,STM32G030F6Px,
U3,SOP-8_3.9x4.9mm_P1.27mm,1,CH340N,
U4,SOT-223-3_TabPin2,1,AMS1117-3.3,

## KiCad design instax_sq/pcb_for_instax_sq/ShutterCal_instax_sq/ShutterCal_instax_sq.kicad_pcb

Parts:
C1, C2: TBD; C_0603_1608Metric
D1: SFH2440; Osram_SFH2440
R1: TBD; R_0603_1608Metric
U1: OPA365xxDBV; SOT-23-5

Connections:
+5V: U1.5 (V+)
GND: C2.2, D1.2 (A), U1.2 (V-)
unnamed: C1.2, R1.2, U1.1
unnamed: C1.1, D1.1 (K), R1.1, U1.4 (-)
unnamed: C2.1, U1.3 (+)

Board: 2 copper layers, 5 parts (0 on the bottom side), 4 nets, no tracks yet.

## Code that names these connections

File code/ShutterMonitor_stm32g030/ShutterMonitor_stm32g030.ioc (part):

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Mcu.Name=STM32G030F6Px
Mcu.Package=TSSOP20
Mcu.UserName=STM32G030F6Px
PA11\ [PA9].Mode=I2C
PA11\ [PA9].Signal=I2C2_SCL
PA12\ [PA10].Mode=I2C
PA12\ [PA10].Signal=I2C2_SDA
PA13.Mode=Serial_Wire
PA13.Signal=SYS_SWDIO
PA14-BOOT0.Mode=Serial_Wire
PA14-BOOT0.Signal=SYS_SWCLK
PA14-BOOT0__PA15.StandardMode=true
PA2.Mode=Asynchronous
PA2.Signal=USART2_TX
PA3.Mode=Asynchronous
PA3.Signal=USART2_RX
PA6.Mode=IN6
PA6.Signal=ADC1_IN6
PB0__PB1__PB2__PA8.StandardMode=true
PB3__PB4__PB5__PB6.StandardMode=true
PB6.Mode=Asynchronous
PB6.Signal=USART1_TX
PB7.Mode=Asynchronous
PB7.Signal=USART1_RX
PB7__PB8.StandardMode=true
PC14-OSC32_IN\ (PC14)__PB9.StandardMode=true
RCC.HSE_VALUE=8000000
RCC.SYSCLKFreq_VALUE=64000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=custom

File code/ShutterMonitor_stm32f070/ShutterMonitor_stm32f070.ioc (part):

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Mcu.Name=STM32F070F6Px
Mcu.Package=TSSOP20
Mcu.UserName=STM32F070F6Px
PA0.Mode=IN0
PA0.Signal=ADC_IN0
PA1.Mode=IN1
PA1.Signal=ADC_IN1
PA11.Mode=Device
PA11.Signal=USB_DM
PA12.Mode=Device
PA12.Signal=USB_DP
PA13.Mode=Serial_Wire
PA13.Signal=SYS_SWDIO
PA14.Mode=Serial_Wire
PA14.Signal=SYS_SWCLK
PA2.Mode=Asynchronous
PA2.Signal=USART2_TX
PA3.Mode=Asynchronous
PA3.Signal=USART2_RX
PA5.Mode=Full_Duplex_Master
PA5.Signal=SPI1_SCK
PA6.Mode=Full_Duplex_Master
PA6.Signal=SPI1_MISO
PA7.Mode=Full_Duplex_Master
PA7.Signal=SPI1_MOSI
PF0-OSC_IN.Mode=HSE-External-Oscillator
PF0-OSC_IN.Signal=RCC_OSC_IN
PF1-OSC_OUT.Mode=HSE-External-Oscillator
PF1-OSC_OUT.Signal=RCC_OSC_OUT
RCC.SYSCLKFreq_VALUE=48000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=custom

## Commit log

2024-02-15 240215
2024-04-09 Create LICENSE
